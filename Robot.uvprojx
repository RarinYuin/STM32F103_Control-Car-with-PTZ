# Keil uVision project Robot.uvprojx, settings and files
target Robot (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Robot_app +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\CORE;.\FWlib\inc;.\HARDWARE\Adc;.\HARDWARE\Beep;.\HARDWARE\Common;.\HARDWARE\encoder;.\HARDWARE\Control_app;.\HARDWARE\encoder;.\HARDWARE\KEY;.\HARDWARE\LED;.\HARDWARE\Motor;.\HARDWARE\OLED;.\HARDWARE\PS2;.\HARDWARE\Servo;.\HARDWARE\Timer;.\SYSTEM\delay;.\SYSTEM\show;.\SYSTEM\sys;.\SYSTEM\usart;.\USER
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CORE
    ./CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWlib
    ./FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HARDWARE
    ./HARDWARE/Adc/: Adc.c
    ./HARDWARE/Beep/: beep.c
    ./HARDWARE/Common/: common.c
    ./HARDWARE/Control_app/: control_app.c
    ./HARDWARE/KEY/: key.c
    ./HARDWARE/LED/: led.c
    ./HARDWARE/Motor/: Motor.c
    ./HARDWARE/OLED/: oled.c
    ./HARDWARE/Servo/: servor.c
    ./HARDWARE/Timer/: timer.c
  group SYSTEM
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/show/: show.c
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/usart/: usart.c
  group USER
    ./USER/: Control.c main.c stm32f10x_it.c system_stm32f10x.c
software components: CMSIS:CORE 5.1.1
